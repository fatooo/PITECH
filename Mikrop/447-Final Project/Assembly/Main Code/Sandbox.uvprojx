# Keil uVision project Sandbox.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Sandbox
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Main.s EmptyPlayfield.s Startup.s SPI_config.s SCREEN_INIT.s DELAY_100ms.s Data_write.s ADDRESS_CHANGE.s DELAY_1ms.s SysTick_Timer.s winner.s LOSER.s PUSHBUTTON.s ADC_INIT.s SHIP_CURSOR.s MEMORY_MAP.s DELAY_1sec.s DELAY_10ms.s PLAYER2_PUSHBUTTON.s MINE_CURSOR.s Player_1.s Player_2.s CUTSCENES.s END_CASE.s Battleship.s
